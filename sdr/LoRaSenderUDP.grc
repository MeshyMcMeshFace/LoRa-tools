<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_width</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>lora_sf</value></param>
<param><key>choices</key><value>[6,7,8,9,10,11,12]</value></param>
<param><key>value</key><value>8</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>LoRa Spreading Factor</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>sdr_freq</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>433e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sdr_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>0,1,1,2</value></param>
<param><key>label</key><value>SDR LNA gain</value></param>
<param><key>max</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>sdr_ppm</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>label</key><value>SDR ppm offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sdr_rate</value></param>
<param><key>value</key><value>int(01e6)</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0</value></param>
<param><key>crc</key><value>False</value></param>
<param><key>center_freq</key><value>sdr_freq</value></param>
<param><key>channel_list</key><value>[sdr_freq]</value></param>
<param><key>cr</key><value>3</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>out_samp_rate</key><value>chan_width</value></param>
<param><key>in_samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>lora_sf</value></param>
</block>
<block>
<key>lora_message_socket_sink</key>
<param><key>id</key><value>lora_message_socket_sink_0</value></param>
<param><key>loraphy</key><value>True</value></param>
<param><key>loratap</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ip</key><value>127.0.0.1</value></param>
<param><key>port</key><value>10541</value></param>
</block>
<block>
<key>lora_message_socket_sink</key>
<param><key>id</key><value>lora_message_socket_sink_1</value></param>
<param><key>loraphy</key><value>False</value></param>
<param><key>loratap</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ip</key><value>127.0.0.1</value></param>
<param><key>port</key><value>10542</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>sdr_ppm</value></param>
<param><key>freq0</key><value>sdr_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>sdr_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sdr_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,4,4</value></param>
<param><key>peak_hold</key><value>True</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>sdr_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>lora_message_socket_sink_1</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>lora_lora_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
